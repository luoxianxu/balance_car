# Keil uVision project project.uvprojx, settings and files
target c8t6project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F103X_MD,USE_STDPERIPH_DRIVER
  c include: ..\LIB\inc;..\SYSTEM;..\USER;.\timer;.\Pid;.\sys;.\delay;.\USART;.\oled;.\MPU6050;.\MPU6050\eMPL;.\timer;.\Exit_Nvic;.\oled;.\motor_control
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ASM
    ../ASM/: startup_stm32f10x_md.s
  group USER
    ./: main.c
    ./timer/: timer.c
    ./delay/: delay.c
    ./USART/: USART.c
    ./sys/: sys.c
    ./MPU6050/: mpu6050.c mpuiic.c
    ./MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./Exit_Nvic/: exit_interrupt.c
    ./oled/: oled.c
    ./motor_control/: motor_control.c
  group SYSTEM
    ../SYSTEM/: core_cm3.c core_cm3.h stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group LIB
    ../LIB/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
